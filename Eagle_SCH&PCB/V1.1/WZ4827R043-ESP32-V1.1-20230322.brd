# Repository Elecrow-RD/CrowPanel-4.3-HMI-ESP32-Display-480x272

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | old |
| 1    | V1.1     | V1.1     | old |
| 1    | V2.0     | V2.0     | old |
| 1    | V2.1     | V2.0     | latest |

**Version 2.0** upgrades the automatic download feature from Version 1.0.

### 3, product information

- Model: 4.3 inches -CrowPanel ESP32 display
- Main Processor: ESP32-S3-WROOM-1-N4R2
- Resolution: 480*272
- Touch Type: Resistive Touch Screen
- Display Type: TN Panel
- Screen: TFT-LCD Screen
- Display driver: NV3047
- External power supply: DC5V-2A
- Interface: 1\*TF Card Slot, 2\* GPIO, 1\*Speak, 2\* UART1, 1\*UART0
- Button: BOOT Button and Reset Button
- Active Area: 95.04\*53.86mm(W*H)
- Working Temperature: -20℃～70℃
- Storage Temperature: -30℃～80℃

### 4, Use the driver module

| Name | dependency library |
| ---- | ------------------ |
| LVGL | lvgl/lvgl@8.3.3    |

### 5,Quick Start

##### Arduino IDE starts

1.Download the library files used by this product to the 'libraries' folder.

C:\Users\Documents\Arduino\libraries\

2.Open the Arduino IDE

3.Open the code configuration environment and burn it

##### ESP-IDF starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the IDF plug-in, select the port, then compile and flash

##### PlatformIO starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the PlatformIO plug-in, select the port, then compile and flash

##### Micropython starts

1,Right-click on an empty space in the project folder and select "Thonny" to open the project.

2,In thonny software, select the master and port, then run the program

### 6,Folder structure.

|--3D file： Contains 3D model files (.stp) for the hardware. These files can be used for visualization, enclosure design, or integration into CAD software.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

|--factory_sourcecode: Contains the source code for the factory firmware, allowing users to modify and rebuild the firmware as needed.

### 7,Pin definition

\#define TOUCH_XPT2046 

#define TOUCH_XPT2046_SCK 12 

#define TOUCH_XPT2046_MISO 13 

#define TOUCH_XPT2046_MOSI 11 

#define TOUCH_XPT2046_CS 0 

#define TOUCH_XPT2046_INT 36

## EAGLE design Eagle_SCH&PCB/V1.1/WZ4827R043-ESP32-V1.1-20230322.brd

Parts:
C2, C4, C10, C13, C20, C24, C33: 100nF; C0603
C3: 1uF; C0603
C6, C8, C18: 1uF; 0603
C7, C19, C42, C43: 22uF; 0805
C9, C21, C26: 100nF; 0603
C11: 4.7uF; 0603
C12, C29, C30, C36: 1uF; DISCRETE_C0603
C14, C16: 1nF; C0603
C15: 0.1uF; DISCRETE_C0603
C17: 0.1uF/NC; DISCRETE_C0603
C22, C27, C28, C35: 100pF; 0603
C23, C31, C37, C38: 10uF; DISCRETE_C0603
C25, C32: 47uF; 0805
C54: 4.7uF; DISCRETE_C0603
D3: SS34/SMB; 214AB
D6: SS24B/SMB; 214AB
J1, J5: PH2.0WT-2PIN
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J4: 2.54-8PIN-WOTIE; 2.54-8P-WOTIE
J7, J10: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
JP1: 0.5MM-40PIN40PIN; 0.5MM*40P
K1, K4: BUTTON; 157SW
L4: 5.6UH; CD54
L5: CD32_6.8uH; CD32
LED1: RED; DISCRETE_LED-0603
Q5: S8050; SPARKFUN_SOT23
Q30: PMOS-3401-4A; SOT-23
R1: 10K/NC; R0603
R2, R4, R10, R12, R18/NC, R19: 0R; DISCRETE_R0603
R3: 4.7K; DISCRETE_R0603
R6, R7: 4.7K/NC; DISCRETE_R0603
R8, R9, R71, R72: 22R; DISCRETE_R0603
R11: 100R; R0603
R13, R14: 5.1K; DISCRETE_R0603
R15, R16, R17, R18, R21, R23, R24, R25, R30, R67: 10K; DISCRETE_R0603
R20: 45.3K; DISCRETE_R0603
R22: 100K; DISCRETE_R0603
R26: 0R; R0603
R29: 10R 1%; DISCRETE_R0603
R31: 10k/NC; R0603
R41: 10K/NC; DISCRETE_R0603
R58: 10k; R0603
R172: 100K; R0603
SD1: HOLDER-MICROSD-9P; 9P-SMD-W/-RING
U1: RY3420; A_XBJ_SOT23-5
U2: ESP32-S; ESP32-S3
U4: MT9201; SOT23-6
U6: CH340C; SOP-16
U8: AO4407A_PMOS; SOP8
U11: NS4168-ESOP-8
U41: XPT2046; XP2046-SSOP16

Connections:
3V3: C2.1, C3.1, C4.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.1, C15.2, C20.1, C23.2, C26.1, C29.2, C30.2, C31.2, C32.2, C33.1, C36.2, C54.2, J4.1, J4.2, J7.3, J10.3, JP1.P$37 (VCC), L4.2, R3.2, R6.1, R7.1, R10.1, R16.1, R17.1, R18.1, R20.1, R22.2, R23.1, R24.1, R25.1, R30.2, R41.1, R67.1, SD1.4 (VDD), U2.2 (3V3), U6.4 (V3), U6.16 (VCC), U41.1 (VCC), U41.9 (VREF), U41.10 (IOVDD)
BAT+: J1.P$1, U8.P$5 (5_D), U8.P$6 (6_D), U8.P$7 (7_D), U8.P$8 (8_D)
D+: J3.A6 (DP1), J3.B6 (DP2), R9.1
D-: J3.A7 (DN1), J3.B7 (DN2), R8.1
DCLK: C17.2, JP1.P$11 (CLK), R26.2
EN_RESET: C11.1, K4.2, R18.2, U2.3 (EN)
GND: C2.2, C3.2, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.1, C13.2, C14.2, C15.1, C16.2, C17.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.2, C35.1, C36.1, C42.1, C43.1, C54.1, J1.P$2, J1.P$3, J1.P$4, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$6, J3.P$7, J3.P$8, J3.P$9, J4.3, J4.4, J5.P$3, J5.P$4, J7.4, J7.SS1, J7.SS2, J10.4, J10.SS1, J10.SS2, JP1.P$5 (GND2), JP1.P$12 (GND4), JP1.P$18 (B2), JP1.P$19 (B1), JP1.P$20 (B0), JP1.P$27 (G1), JP1.P$28 (G0), JP1.P$34 (R2), JP1.P$35 (R1), JP1.P$36 (R0), JP1.P$38 (GND3), JP1.P$41 (GND5), JP1.P$42 (GND6), K1.1, K4.1, LED1.-, Q5.2 (E), R1.1, R13.1, R14.2, R15.1, R21.2, R29.2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
I2S_BCLK: R19.1, U11.3 (BCLK)
I2S_CTRL: R22.1, U11.1 (CTRL)
I2S_SDIN: R4.1, U11.4 (SDATA)
IO0_BOOT: K1.2, R2.1, U2.27 (IO0)
IO1_B7: JP1.P$13 (B7), U2.39 (IO1)
IO2_LCD_BL_CTR: R11.2, U2.38 (IO2), U4.4 (4-EN)
IO3_B4: JP1.P$16 (B4), U2.15 (IO3)
IO4_G7: JP1.P$21 (G7), U2.4 (IO4)
IO5_G2: JP1.P$26 (G2), U2.5 (IO5)
IO6_G3: JP1.P$25 (G3), U2.6 (IO6)
IO7_G4: JP1.P$24 (G4), U2.7 (IO7)
IO8_B3: JP1.P$17 (B3), U2.12 (IO8)
IO9_B6: JP1.P$14 (B6), U2.17 (IO9)
IO10_TF_CS: R67.2, SD1.2 (CS), U2.18 (IO10)
IO11_TF_SPI_MOSI/TP_DIN: R23.2, SD1.3 (DI), U2.19 (IO11), U41.14 (DIN)
IO12_TF_CLK/TP_CLK: SD1.5 (SCLK), U2.20 (IO12), U41.16 (DCLK)
IO13_TF_SPI_MISO/TP_OUT: R24.2, SD1.7 (DO), U2.21 (IO13), U41.12 (DOUT)
IO14_R7: JP1.P$29 (R7), U2.22 (IO14)
IO15_G5: JP1.P$23 (G5), U2.8 (IO15)
IO16_G6: JP1.P$22 (G6), U2.9 (IO16)
IO17_TXD1: J4.6, J10.2, U2.10 (IO17)
IO18_RXD1: J4.5, J10.1, U2.11 (IO18)
IO19_I2S_MCLK: R12.2, U2.13 (IO19)
IO20_I2S_SDIN: R4.2, U2.14 (IO20)
IO21_R6: JP1.P$30 (R6), U2.23 (IO21)
IO35_I2S_BCLK: R19.2, U2.28 (NC1)
IO36_TP_IRQ: R30.1, U2.29 (NC2), U41.11 (PENIRQ)
IO37_I2C_SDA: J4.8, J7.2, R7.2, U2.30 (NC3)
IO38_I2C_SCL: J4.7, J7.1, R6.2, U2.31 (IO38)
IO39_HSYNC: JP1.P$9 (HSYNC), U2.32 (IO39)
IO40_DE: JP1.P$7 (DE), U2.33 (IO40)
IO41_VSYNC: JP1.P$8 (VSYNC), U2.34 (IO41)
IO42_CLK_DCLK: R26.1, U2.35 (IO42)
IO45_R3: JP1.P$33 (R3), R31.2, U2.26 (IO45)
IO46_B5: JP1.P$15 (B5), U2.16 (IO46)
IO47_R5: JP1.P$31 (R5), U2.24 (IO47)
IO48_R4: JP1.P$32 (R4), U2.25 (IO48)
LCD_LEDA: C19.2, C21.2, D6.2 (-), JP1.P$39 (LEDA), U4.5 (5-OV)
LCD_LEDK: JP1.P$40 (LEDK), R29.1, U4.3 (3-FB)
LRCLK: R12.1, U11.2 (LRCLK)
unnamed: LED1.+, R3.1
unnamed: R41.2, U41.7 (VBAT)
unnamed: C37.2, U11.8 (VOP)
unnamed: C14.1, C37.1, J5.P$2
unnamed: JP1.P$10 (DISP), R25.2
unnamed: R1.2, R2.2, U41.15 (CS)
unnamed: C16.1, C38.1, J5.P$1
unnamed: J3.A5 (CC1), R13.2
unnamed: C38.2, U11.5 (VON)
unnamed: L4.1, U1.3 (SW)
unnamed: D6.1 (+), L5.2, U4.1 (1-SW)
unnamed: J3.B5 (CC2), R14.1
unnamed: R20.2, R21.1, U1.5 (FB)
unnamed: Q5.1 (B), R11.1, R58.2
unnamed: Q5.3 (C), Q30.1 (G), R172.2
unnamed: R72.2, U6.2 (TXD)
unnamed: R71.2, U6.3 (RXD)
unnamed: R16.2, SD1.1 (DATA2)
unnamed: R17.2, SD1.8 (DATA1)
TP_X+: C35.2, JP1.P$4 (XR), U41.2 (XP)
TP_X-: C27.2, JP1.P$2 (XL), U41.4 (XN)
TP_Y+: C28.2, JP1.P$3 (YD), U41.3 (YP)
TP_Y-: C22.2, JP1.P$1 (YU), U41.5 (YN)
UART0_RXD0: R72.1, U2.36 (RXD0)
UART0_TXD0: R71.1, U2.37 (TXD0)
USB_D+: R9.2, U6.5 (UD+)
USB_D-: R8.2, U6.6 (UD-)
VBUS: D3.1 (+), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R15.2, U8.P$4 (4_G)
VDD: C24.1, C25.1, R10.2, R18/NC.2, U11.6 (VDD)
VIN: C6.2, C42.2, D3.2 (-), Q30.2 (S), R18/NC.1, R172.1, U1.1 (EN), U1.4 (VIN), U8.P$1 (1_S), U8.P$2 (2_S), U8.P$3 (3_S)
VIN2: C18.2, C43.2, L5.1, Q30.3 (D), U4.6 (6-VIN)

Notes on the sheet:
Vout=0.6*(R20/R21 +1)=3.3V
系统3.3V电源
UART1接口
主控 ESP32-S3-WROOM-1-N4R2
USB type-c座子
电池及控制电路
IO0: 低电平：下载启动 高电平：SPI启动
EN: 高电平：芯片使能； 低电平：芯片关闭。
USB转串口
IIS 功放:NS4168
TF Card
BOOT
RESET
POWER LED
LCD+TP 接口
TP驱动:XPT2046
Vout=0.6*(1+RU/RN)
HM3416H更换为RY3420

Board: 2 copper layers, 121.7 x 71.5 mm, 100 parts (1 on the bottom side), 78 nets.

Other parts of the board:
U$10: 4.3底部丝印
U$30: ELECROW-NEW
U$33: 4.3板框

## Commit log (part)

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2026-04-19 Fix formatting of interface line in readme.md
2026-06-16 V2.1
2026-06-22 Micropython
2026-06-22 ESP_IDF
2026-06-23 PlatformIO
2026-06-25 .gitignore
2026-06-25 .pio
